# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: libQfplib (library)
  group Qfplib
    ../Qfplib-M0-tiny/: qfpio_gcc.S qfplib_gcc.S
